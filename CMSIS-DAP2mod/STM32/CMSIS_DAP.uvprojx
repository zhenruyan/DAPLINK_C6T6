# Keil uVision project CMSIS_DAP.uvprojx, settings and files
target CMSIS-DAP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CMSIS_DAP +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=5
  c define: USE_STDPERIPH_DRIVER STM32F10X_LD STM32F103Cx BOARD_V1M
  c include: .;.\STM32F10x_StdPeriph_Driver\inc;.\USBStack\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group CMSIS-DAP
    ./: system_stm32f10x.c CMSIS-DAP.c UserApp.c usb_config.c usbd_STM32F103.c usbd_user_cdc_acm.c usbd_user_hid.c DAP_config.h startup_stm32f10x_ld.s
  group Lib
    ./STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c misc.c
  group usb
    ./USBStack/src/: usbd_cdc_acm.c usbd_core.c usbd_core_cdc.c usbd_core_hid.c usbd_hid.c
software components: CMSIS:CORE 5.6.0
